# Keil uVision project studiow1-traffic.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: studiow1-traffic
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: PLL.s startup.s TrafficLight.s
software components: CMSIS:CORE 5.3.0
